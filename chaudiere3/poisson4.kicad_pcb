# Repository levraidieu/aquarium-wifi

## KiCad design chaudiere3/poisson4.kicad_pcb

Parts:
C1: CP; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_D3.0mm
J1: Conn_02x12_Top_Bottom; atx_couder_femelle
J2: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J3, J4, J5, J6, J7, J10, J12, J14, J16, J18, J19, J20, J21, J25, J26, J27, J28: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
J8: Conn_02x05_Counter_Clockwise; PinHeader_2x05_P2.54mm_Vertical-fred
J9: Conn_02x05_Top_Bottom; PinHeader_2x05_P2.54mm_Vertical-fred
J11, J13, J15, J17, J22, J23, J24: Screw_Terminal_01x02; bornier_2pts_L10mm_W8mm
Q1, Q2, Q3, Q4, Q5: BC548; TO-92_Inline
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U2: ESP8266EX-NODEMCU-FRED-chaudier; ESP12F-Devkit-V3-fred-GPIO

Connections:
+3V3: J1.1, J1.2, J1.12, J1.13, J24.1, R1.1, R19.1, U2.11 (3.3V), U2.16 (3.3V), U2.25 (3.3V)
+5V: J1.4, J1.6, J1.22, J2.1, J9.5, J23.1, Q1.1 (C), Q2.1 (C), R10.1, R12.1, R14.1, R15.1, R16.1, R18.1
+12V: J1.10, J1.11, J22.1, R17.1
GND: D6.1 (K), D7.1 (K), D8.1 (K), J1.3, J1.7, J1.15, J1.19, J1.24, J3.2, J4.2, J5.2, J6.2, J7.2, J9.6, J10.2, J11.2, J12.2, J13.2, J14.2, J15.2, J16.2, J17.2, J18.2, J19.2, J20.2, J21.2, J22.2, J23.2, J24.2, J25.2, J26.2, J27.2, J28.2, Q3.3 (E), Q4.3 (E), Q5.3 (E), R6.1, U2.10 (GND), U2.14 (GND), U2.17 (GND), U2.24 (GND)
unnamed: D1.1 (K), Q3.1 (C)
unnamed: D1.2 (A), R10.2
unnamed: D2.1 (K), D5.1 (K), Q4.1 (C)
unnamed: D2.2 (A), R12.2
unnamed: D3.1 (K), D4.1 (K), Q5.1 (C)
unnamed: D3.2 (A), R14.2
unnamed: D4.2 (A), R15.2
unnamed: D5.2 (A), R16.2
unnamed: D6.2 (A), R17.2
unnamed: D7.2 (A), R18.2
unnamed: D8.2 (A), R19.2
unnamed: J1.16, J25.1
unnamed: J2.2, U2.15 (5V)
unnamed: J3.1, R1.2, R2.2, U2.1 (TOUT)
unnamed: J4.1, R2.1, R3.2
unnamed: J5.1, R3.1, R4.2
unnamed: J6.1, R4.1, R5.2
unnamed: J7.1, R5.1, R6.2
unnamed: J8.1, J8.2, J8.3, J8.4, J8.5, U2.29 (Gpio5)
unnamed: J8.6, J8.7, J8.8, J8.9, J8.10, U2.28 (Gpio4)
unnamed: J9.1, U2.5 (Gpio9)
unnamed: J9.2, U2.4 (Gpio10)
unnamed: J9.3, Q2.3 (E)
unnamed: J9.4, Q1.3 (E)
unnamed: J9.7, U2.9 (Gpio6)
unnamed: J9.8, U2.8 (Gpio7)
unnamed: J9.9, U2.7 (Gpio11)
unnamed: J9.10, U2.6 (Gpio8)
unnamed: J10.1, J11.1, J18.1, R9.1, U2.20 (Gpio15)
unnamed: J12.1, J13.1, J19.1, R13.1, U2.23 (Gpio14)
unnamed: J14.1, J15.1, J20.1, U2.19 (Gpio3)
unnamed: J16.1, J17.1, J21.1, U2.18 (Gpio1)
unnamed: Q1.2 (B), R7.2
unnamed: Q2.2 (B), R8.2
unnamed: Q3.2 (B), R9.2
unnamed: Q4.2 (B), R11.1
unnamed: Q5.2 (B), R13.2
unnamed: R7.1, U2.26 (Gpio2)
unnamed: R8.1, U2.27 (Gpio0)
unnamed: R11.2, U2.22 (Gpio12)
unnamed: J27.1, U2.21 (Gpio13)
unnamed: J26.1, J28.1, U2.30 (Gpio16)

Notes on the sheet:
retro-eclairage
RELAIS SSR
RELAIS MECANIQUE
Sonde temperataure ballon
Sonde temperataure chaudiere
voyant demande temperature au sonde
CLAVIER
i2c
ALIMENTATION

Parts:
J1: Conn_02x12_Top_Bottom

Connections:
+3V3: J1.1, J1.2, J1.12, J1.13; also elsewhere on the board
+5V: J1.4, J1.6, J1.22; also elsewhere on the board
+12V: J1.10, J1.11; also elsewhere on the board
GND: J1.3, J1.7, J1.15, J1.19, J1.24; also elsewhere on the board
unnamed 19: J1.16; also elsewhere on the board

Notes on the sheet:
retro-eclairage
contraste
LCD
RELAIS SSR
RELAIS MECANIQUE
Sonde temperataure ballon
Sonde temperataure chaudiere
voyant demande temperature au sonde
CLAVIER
i2c

Board: 2 copper layers, 100.0 x 100.0 mm, 58 parts (0 on the bottom side), 44 nets.

## Commit log

2019-09-26 Create test.txt
    aqua
2019-09-29 capteur
    capteur
2019-09-29 visual studio code
2019-09-29 boutonaquarium.ccp
2019-09-29 rajout port E/S
2019-09-29 modif nomE/S
    modif dans wifi des nom des ports de sorties
2019-09-29 wifi
2019-09-29 Update sms-modulaire.cpp
    epuration
2019-09-30 ds1820
2019-10-08 ds1820 indexation
2019-10-08 ds1820 capteur default
2019-10-08 test
2019-10-09 test compile arduino
2019-10-10 divers sms
2019-10-10 sms + temperature
2019-10-11 relais chauffe eau
2019-10-16 EXEMPLE SMTP
2019-10-17 test avec le logiciel arduino
2019-10-17 ERROR
    c:/users/damien/appdata/local/arduino15/packages/esp8266/tools/xtensa-lx106-elf-gcc/2.5.0-3-20ed2b9/bin/../lib/gcc/xtensa-lx106-elf/4.8.2/../../../../xtensa-lx106-elf/bin/ld.exe: C:\Users\damien\AppD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
    collect2.exe: error: ld returned 1 exit status
2019-10-17 extern struct ts t;
    extern struct ts t; //dans temperature pour regler pb de declaration multiple
2019-10-18 mise a jour arduino
2019-10-18 mise a jour de nom de fonction dans wifi
2019-10-24 Update sketch_jul27a.ino
    description fonctionnaliter du prog
2019-10-25 Update sketch_jul27a.ino
    ntp
2019-10-26 web nourriture
2019-10-26 Update progHoraire3231.cpp
    web lumiere et nourriture
2019-11-03 emprunte kicad et ino
2019-11-03 thingspeak
2019-11-04 hgfhgf
2019-11-13 bornier 2 visses
2019-11-14 KICAD 8266
2019-11-15 mise a jour repertoire
2019-11-19 pdf chaudiere
2019-11-21 impression
2019-11-23 resistance
2019-11-25 kicad creation empreite led pastille
2019-11-26 Create poisson4.kicad_pcb
    typon chaudiere
2019-11-28 chaudiere kicad
2019-11-29 ch340
2019-12-02 GFFH
2020-01-16 prog aruino
